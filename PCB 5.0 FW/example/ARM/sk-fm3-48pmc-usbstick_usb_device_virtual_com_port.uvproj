# Keil uVision project sk-fm3-48pmc-usbstick_usb_device_virtual_com_port.uvproj, settings and files
target MB9AF311K_Debug (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: sk-fm3-48pmc-usbstick_usb_device_virtual_com_port
  c flags: Optim=1
  c include: ..\..\common;..\..\example\source;../source/sk-fm3-48pmc-usbstick;../source/filesystem/elm-chan.org;../source/l3;../source/l3;../source/UsbMiddleWare;../source/UsbConfig
  memory RVCT4: ROM 0x1fffe000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group common
    ../../common/: system_mb9af31x.c
  group source_files
    ../source/: main.c
    ../../: Readme.txt
    ./: startup_mb9af31x.s FLASH_DEBUG_README.txt
  group /sk-fm3-48pmc-usbstick
    ../source/sk-fm3-48pmc-usbstick/: board.c board.h button.c button.h led.h ledpwm.c ledpwm.h sensoradc.c sensoradc.h uart.c uart.h
  group /filesystem/elm-chan.org
    ../source/filesystem/elm-chan.org/: ccsbcs.c diskio.c diskio.h ff.c ff.h integer.h README_fs.txt
  group /l3
    ../source/l3/: adc.c adc.h base_types_l3.h bt.c bt.h can.c can.h clk.c clk.h crc.c crc.h crtrim.c crtrim.h csv.c csv.h dac.c dac.h dma.c dma.h dsm.c dsm.h dt.c dt.h exint.c exint.h extif.c extif.h flash.c flash.h gpio1pin.h interrupts.c interrupts.h l3.c l3.h l3_user.h lvd.c lvd.h mfs.c mfs.h mft.c mft.h qprc.c qprc.h ramcode.c ramcode.h reset.c reset.h rtc.c rtc.h usb.c usb.h usbdevice.c usbdevice.h usbethernetclock.c usbethernetclock.h usbhost.c usbhost.h wc.c wc.h wdg.c wdg.h
  group /l3
    ../source/l3/: base_types_l3.h usb.c usb.h usbdevice.c usbdevice.h usbethernetclock.c usbethernetclock.h usbhost.c usbhost.h
  group /UsbMiddleWare
    ../source/UsbMiddleWare/: UsbClassSupervisor.c UsbClassSupervisor.h UsbDeviceCdcCom.c UsbDeviceCdcCom.h UsbHostHidCom.c UsbHostHidCom.h UsbHostHidKeyboard.c UsbHostHidKeyboard.h UsbHostHidMouse.c UsbHostHidMouse.h UsbHostMassStorage.c UsbHostMassStorage.h
  group /UsbConfig
    ../source/UsbConfig/: ClassDriverTable.h UsbConfig.c usbconfig.h usbdescriptors.h usbdevicehw.h usbhosthw.h
target MB9AF312K_Debug (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: sk-fm3-48pmc-usbstick_usb_device_virtual_com_port
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x1fffe000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x2000
target MB9AF311K_Release (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: sk-fm3-48pmc-usbstick_usb_device_virtual_com_port +hex
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1fffe000 size 0x4000
target MB9AF312K_Release (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: sk-fm3-48pmc-usbstick_usb_device_virtual_com_port
  c flags: Optim=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x4000
