# IAR project Backup of sk-fm3-48pmc-usbstick_usb_device_virtual_com_port.ewp, settings and files
configuration MB9AF312K_Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\example\source; ..\..\example\source\My; ..\..\example\source\l3; ..\..\example\source\sk-fm3-48pmc-usbstick; ..\..\example\source\sk-fm3-48pmc-usbstick\adc; ..\..\example\source\sk-fm3-48pmc-usbstick\ppg; ..\..\example\source\usbconfig; ..\..\example\source\UsbMiddleWare; ..\..\example\source\common; ..\..\example\source\filesystem\elm-chan.org
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sk-fm3-48pmc-usbstick_usb_device_virtual_com_port.srec
  ILINK.IlinkOutputFile: sk-fm3-48pmc-usbstick_usb_device_virtual_com_port.out
  ILINK.IlinkIcfFile: config\mb9af312.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: EWARM_6_30_7_README.txt
    ../../: Readme.txt
  group common
    ../../common/: system_mb9af31x.c
  group My
    ../source/My/: 1wire.c AT45DB161.c Atlas_C.c Atlas_TC.c AtlasReplacement.c command.c constants.c delay.c DS18B20.c DualTimer.c gpio.c gprs.c GprsUart.c i2c.c mmu.c mybootloader.c myfun.c MyUsb.c PAE800.c PAE_I2C.c ProjectFunc.c SerialHmi.c SerialPort.c VARIABLE.C
  group My/MY HEADER FILES
    ../source/My/: 1wire.h AT45DB161.h Atlas_C.h Atlas_TC.h AtlasReplacement.h command.h common.h delay.h DS18B20.h DualTimer.h gpio.h gprs.h GprsUart.h i2c.h mmu.h mybootloader.h myfun.h MyUsb.h PAE800.h PAE_I2C.h ProjectFunc.h SerialHmi.h SerialPort.h VARIABLE.h
  group source_files
    ../source/: main.c
    ./: startup_mb9af31x.s
  group source_files/filesystem/elm-chan.org
    ../source/filesystem/elm-chan.org/: ccsbcs.c diskio.c diskio.h ff.c ff.h integer.h README_fs.txt
  group source_files/l3
    ../source/l3/: base_types_l3.h bt.c bt.h can.c can.h clk.c clk.h crc.c crc.h crtrim.c crtrim.h csv.c csv.h dac.c dac.h dma.c dma.h dsm.c dsm.h dt.c dt.h exint.c exint.h extif.c extif.h flash.c flash.h gpio1pin.h interrupts.c interrupts.h l3.c l3.h l3_user.h lvd.c lvd.h mfs.c mfs.h mft.c mft.h qprc.c qprc.h ramcode.c ramcode.h reset.c reset.h rtc.c rtc.h usb.c usb.h usbdevice.c UsbDevice.h usbethernetclock.c usbethernetclock.h usbhost.c usbhost.h wc.c wc.h wdg.c wdg.h
  group source_files/sk-fm3-48pmc-usbstick
    ../source/sk-fm3-48pmc-usbstick/: board.c board.h button.c button.h led.h ledpwm.c ledpwm.h uart.c uart.h
  group source_files/sk-fm3-48pmc-usbstick/adc
    ../source/sk-fm3-48pmc-usbstick/adc/: adc.c adc.h
  group source_files/sk-fm3-48pmc-usbstick/ppg
    ../source/sk-fm3-48pmc-usbstick/ppg/: ppg.c ppg.h
  group source_files/UsbConfig
    ../source/usbconfig/: ClassDriverTable.h usbconfig.h
    ../source/UsbConfig/: UsbConfig.c usbdescriptors.h usbdevicehw.h usbhosthw.h
  group source_files/UsbMiddleWare
    ../source/UsbMiddleWare/: UsbClassSupervisor.c UsbClassSupervisor.h UsbDeviceCdcCom.c UsbDeviceCdcCom.h UsbHostHidCom.c usbhosthidcom.h UsbHostHidKeyboard.c UsbHostHidKeyboard.h UsbHostHidMouse.c UsbHostHidMouse.h UsbHostMassStorage.c UsbHostMassStorage.h
