<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sk-fm3-48pmc-usbstick_usb_device_virtual_com_port.ewp</path>
  </project>
  <batchBuild/>
</workspace>


